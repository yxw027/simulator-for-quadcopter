# Keil uVision project project.uvproj, settings and files
target AHRS (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group bsp
    ../../bsp/: led.h
  group bsp/stm32f10x
    ../../bsp/: uart.c i2c.c led.c
    ../../bsp/stm32f10x/: stm32f10x_led.c
  group math
    ../../math/: euler.c quaternion.c
  group prj
    ../: main.c stm32f10x_it.c system_stm32f10x.c
