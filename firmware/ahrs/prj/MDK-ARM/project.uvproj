# Keil uVision project project.uvproj, settings and files
target AHRS (ARM-ADS)
  device: STM32F101RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group bsp
    ../../bsp/: led.h
  group bsp/stm32f10x
    ../../bsp/: uart.c i2c.c led.c
  group math
    ../../math/: euler.c
  group prj
    ../: main.c stm32f10x_it.c system_stm32f10x.c
